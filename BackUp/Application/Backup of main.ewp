# IAR project Backup of main.ewp, settings and files
configuration _FLASH_ (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x900
  General.SCRStackSize: 64
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m32 ATmega32
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.newCCIncludePaths: Application; Core; Driver; Config; Module; Class
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: Core\lnkm1280s.xcl
  group Application
    Application/: Oven.cpp
  group Core
    Core/: defines.c
  group Driver
    Driver/: lcd.c timer.c
  group Main
    Main/: main.cpp
  group Module
    Module/: Display.cpp
