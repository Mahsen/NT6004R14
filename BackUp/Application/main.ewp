# IAR project main.ewp, settings and files
configuration _FLASH_ (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x900
  General.SCRStackSize: 64
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m16a ATmega16A
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.newCCIncludePaths: Application; Core; Driver; Config; Module; Class
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm16as.xcl
  group Main
    Main/: main.cpp
